# Keil uVision project MODBUS.uvproj, settings and files
target MODBUS (MCS-51)
  device: STC15F104W STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: MODBUS +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\c_and_h
  asm include: ..\c_and_h
  group Source
    ./: STARTUP.A51
    ../c_and_h/: main.c UART.c MODBUS_Drive.c
  group Include
    ../c_and_h/: all.h UART.h MODBUS_Drive.h
